Properties of the parts of a building model (IFC4X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 51c54441-6f01-48b4-846c-efa56e7491f9, NumberOfSaves: 6], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Internal]
File name: 01K106-KSI-XX-ZZ-M3-Z-0001.ifc
Time: 2025-06-17T09:40:34+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Kingspan Kooltherm® K106

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Pset_SpaceCommon - Reference: Project Information; IsExternal: no
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K106; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no; sets with these values: 2
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K106; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Circle Head - Project Datum
Pset_SpaceCommon - IsExternal: no; Reference: Circle Head - Project Datum
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 0
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcBuildingElementProxy: Model Text:600mm KI_CenturyGothic (2)
In: Level 0
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: 600mm KI_CenturyGothic
Type - Text - Bold: no; Italic: no; Text Font: Century Gothic; Text Size: 600 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 600mm KI_CenturyGothic
Pset_EnvironmentalImpactIndicators - Reference: 600mm KI_CenturyGothic
Other - Family: Model Text; Family and Type: Model Text: 600mm KI_CenturyGothic; Type: 600mm KI_CenturyGothic; Type Id: 305799
Constraints - Work Plane: Level : Level 0
Dimensions - Depth: 150 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Model Text:600mm KI_CenturyGothic:...) | Text
305753 | Kingspan Kooltherm K106 - 90mm
305761 | Kingspan Kooltherm K106 - 115mm

# IfcCovering: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-115, Basic Wall:KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-115:307463
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K106-CavityBoard-115 115 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 115 mm
Type - Dimensions - Length: 1200mm; Thickness: 115mm; Width: 450mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Full fill cavity wall phenolic insulation.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k106-cavity-board-gb-and-ireland/kingspan-kooltherm-k106-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K106; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K106.115mm.BIM-1016.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K106-115mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-115; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k106-cavity-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.165217 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 6.05263 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.165217 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-115
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-115
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-115; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K106; Manufacturer: Kingspan Insulation Ltd; Type Comments: K106-115mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k106-cavity-board/; Description: Full fill cavity wall phenolic insulation.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 450; Width: 115; Thickness: 115mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k106-cavity-board-gb-and-ireland/kingspan-kooltherm-k106-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K106.115mm.BIM-1016.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-115; Type: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-115; Type Id: 307488
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1200 mm
Dimensions - Area: 0.54 m2; Length: 450 mm; Volume: 0.0621 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-90, Basic Wall:KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-90:307184
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K106-CavityBoard-90 90 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Width: 90 mm; Wrapping at Inserts: Both
Type - Dimensions - Length: 1200mm; Thickness: 90mm; Width: 450mm
Type - Graphics - Coarse Scale Fill Color: 12632256; Coarse Scale Fill Pattern: <Solid fill>
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Full fill cavity wall phenolic insulation.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k106-cavity-board-gb-and-ireland/kingspan-kooltherm-k106-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K106; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K106.90mm.BIM-1015.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K106-90mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-90; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k106-cavity-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Heat Transfer Coefficient (U): 0.211111 kg/K/s3; Roughness: 3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.73684 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.211111 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-90
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-90
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-90; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K106; Manufacturer: Kingspan Insulation Ltd; Type Comments: K106-90mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k106-cavity-board/; Description: Full fill cavity wall phenolic insulation.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 450; Width: 90; Thickness: 90mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k106-cavity-board-gb-and-ireland/kingspan-kooltherm-k106-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K106.90mm.BIM-1015.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-90; Type: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard-90; Type Id: 307374
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1200 mm
Dimensions - Area: 0.54 m2; Length: 450 mm; Volume: 0.0486 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K106-CavityBoard-90
Identity - Class: Generic
Thermal - Name: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard(2); Description: Full fill cavity wall phenolic insulation.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Density: 0 kg/m3; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; Permeability: 0 s/m; Reflectivity: 0; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Full fill cavity wall phenolic insulation.; Manufacturer: Kingspan Insulation Ltd; Model: K106-90mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k106-cavity-board/
Materials and Finishes - Color: 8820953; Glow: no; Name: KingspanInsulation01GB_Insulation_Kooltherm-K106-CavityBoard-90; Shininess: 64; Smoothness: 50; Transparency: 0

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K106-CavityBoard-115
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K106-CavityBoard(1); Description: Full fill cavity wall phenolic insulation.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Full fill cavity wall phenolic insulation.; Manufacturer: Kingspan Insulation Ltd; Model: K106-115mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k106-cavity-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K106-CavityBoard-115; Shininess: 64; Smoothness: 50
